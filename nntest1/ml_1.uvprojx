# Keil uVision project ml_1.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKL46Z256xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFE000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ml_1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEBUG=1, CPU_MKL46Z256VLL4, USB_STACK_BM, FRDM_KL46Z, FREEDOM
  c misc: --library_interface=armcc --library_type=standardlib
  c include: ..;.\;.\drivers;.\usb_1.1.0
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: .\MKL46Z256xxx4_flash.scf
  link misc: --remove
  group Main
    ./: mian.c DL_Math.c DL_Math.h ML_Models.c ML_Models.h
  group Board Application
    ./: App_LED.c clock_config.c clock_config.h pin_mux.c pin_mux.h MKL46Z4_features.h
    ./drivers/: fsl_clock.c fsl_smc.c fsl_common.c fsl_debug_console.c fsl_uart.c fsl_lpsci.c
  group USB_Lib
    ./: USB_CDC.c usb_device_cdc_acm.c usb_device_ch9.c usb_device_descriptor.c MKL46Z4.h USB_CDC.h usb_device_cdc_acm.h usb_device_ch9.h usb_device_config.h usb_device_descriptor.h
  group USB_Driver
    ./usb_1.1.0/: usb.h usb_device.h usb_device_dci.h usb_device_khci.h usb_khci.h usb_misc.h usb_osa.h usb_osa_bm.h usb_osa_freertos.h usb_spec.h usb_device_dci.c usb_device_khci.c usb_osa_bm.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
